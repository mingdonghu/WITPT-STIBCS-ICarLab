# Keil uVision project SeekFree_Kinetis.uvprojx, settings and files
target SeekFree_MK60DN (5050106::V5.05 update 1 (build 106)::ARMCC)
  device: MK60DN512xxx10 Freescale
  pack: Keil.Kinetis_K60_DFP.1.0.1
  cpu: IROM(0x00000000,0x80000) IRAM(0x20000000,0x10000) IRAM2(0x1FFF0000,0x10000) CPUTYPE("Cortex-M4") CLOCK(12000000) ELITTLE
  output: SeekFree_Kinetis +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: MK60DN
  c include: ..\USER\inc;..\USER\src;..\..\Libraries\startup\CoreSupport;..\..\Libraries\startup\DeviceSupport\MDK-ARM;..\..\Libraries\startup\DeviceSupport;..\..\Libraries\drives\inc;..\..\Libraries\drives\src;..\..\Libraries\seekfree;..\..\Libraries\FatFs;..\..\Libraries\FatFs\option;..\USER\oled;..\USER\MPU6050;..\USER\MPU6050\eMPL;..\USER\Date_analyse
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x1fff0000 size 0x20000
  group startup
    ../../Libraries/startup/DeviceSupport/MDK-ARM/: startup_MK60F15.s startup_MK60D10.s
    ../../Libraries/startup/DeviceSupport/: system_MK60.c
  group drives_h
    ../../Libraries/drives/inc/: common.h headfile.h misc.h MK60_adc.h MK60_cmt.h MK60_dac.h MK60_dma.h MK60_flash.h MK60_ftm.h MK60_gpio.h MK60_i2c.h MK60_lptmr.h MK60_pit.h MK60_port.h MK60_port_cfg.h MK60_rtc.h MK60_sdhc.h MK60_spi.h MK60_systick.h MK60_uart.h MK60_wdog.h
  group drives_c
    ../../Libraries/drives/src/: common.c misc.c MK60_adc.c MK60_cmt.c MK60_dac.c MK60_dma.c MK60_flash.c MK60_ftm.c MK60_gpio.c MK60_i2c.c MK60_lptmr.c MK60_pit.c MK60_port.c MK60_rtc.c MK60_sdhc.c MK60_spi.c MK60_systick.c MK60_uart.c MK60_wdog.c
  group user_h
    ../USER/inc/: isr.h
    ../../Libraries/drives/inc/: headfile.h
  group user_c
    ../USER/src/: isr.c main.c
    ../../Libraries/: version.txt
  group oled
    ../USER/oled/: myspi.c oled.c
  group seekfree
    ../../Libraries/seekfree/: SEEKFREE_7725.c SEEKFREE_7725.h SEEKFREE_FUN.c SEEKFREE_FUN.h SEEKFREE_IIC.c SEEKFREE_IIC.h SEEKFREE_L3G4200D.c SEEKFREE_L3G4200D.h SEEKFREE_MMA8451.c SEEKFREE_MMA8451.h SEEKFREE_MPU6050.c SEEKFREE_MPU6050.h SEEKFREE_MT9V032.c SEEKFREE_MT9V032.h SEEKFREE_NRF24L01.c SEEKFREE_NRF24L01.h SEEKFREE_TSL1401.c SEEKFREE_TSL1401.h
  group fatfs
    ../../Libraries/FatFs/: 00readme.txt diskio.c diskio.h ff.c ff.h ffconf.h integer.h
  group mpu6050
    ../USER/MPU6050/: mpu6050.c myiic.c
    ../USER/MPU6050/eMPL/: inv_mpu.c inv_mpu_dmp_motion_driver.c
  group Date_analyse
    ../USER/Date_analyse/: Date_analyse.c Date_analyse.h
target SeekFree_MK60FX (ARM-ADS)
  device: MK60FX512xxx15 Freescale
  pack: Keil.Kinetis_K60_DFP.1.0.1
  cpu: IROM(0x00000000,0x80000) IROM2(0x10000000,0x80000) IRAM(0x20000000,0x10000) IRAM2(0x1FFF0000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: SeekFree_Kinetis
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: MK60FX
  c include: ..\USER\inc;..\USER\src;..\..\Libraries\startup\CoreSupport;..\..\Libraries\startup\DeviceSupport\MDK-ARM;..\..\Libraries\startup\DeviceSupport;..\..\Libraries\drives\inc;..\..\Libraries\drives\src;..\..\Libraries\seekfree;..\..\Libraries\FatFs;..\..\Libraries\FatFs\option
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT5: ROM 0x10000000 size 0x80000
  memory RVCT9: RAM 0x1fff0000 size 0x20000
