# IAR project vcan_Kinetis.ewp, settings and files
configuration KEA128_Debug (ARM, debug)
  General.OGChipSelectEditMenu: KEAZ128xxx4 Freescale KEAZ128xxx4
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 35
  General.FPU2: 0
  ICCARM.CCDefines: DEBUG_MODE; ARM_MATH_CM0PLUS; MKEA128
  ICCARM.CCIncludePath2: ..\..\User; ..\..\User\app; ..\..\User\bsp\oled; ..\..\Lib\Chip\inc; ..\..\Lib\Chip\inc\IAR; ..\..\Lib\Chip\inc\kinetis; ..\..\Lib\CMSIS\Inc; ..\..\Lib\VcanBoard\inc
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: vcan_Kinetis.bin
  ILINK.IlinkOutputFile: vcan_Kinetis.out
  ILINK.IlinkIcfFile: config files\vcan_ROM_KEA128.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration KEA128_Release (ARM)
  as the first configuration, except:
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: ARM_MATH_CM0PLUS; MKEA128
  ICCARM.CCOptLevel: 3
  group App
    ../../User/app/: main.c MKEA128_conf.c MKEA128_conf.h MKEA128_it.c MKEA128_it.h PORT_cfg.h
  group App/User
    ../../User/app/: control.c direction.c speed.c
    ../../User/bsp/oled/: myspi.c oled.c
  group App/User_h
    ../../User/app/: control.h direction.h myspi.h speed.h
    ../../User/bsp/oled/: oled.h oledfont.h
  group Board
    ../../Lib/VcanBoard/src/: VCAN_ASCII.c VCAN_computer.c VCAN_key.c VCAN_key_event.c VCAN_LCD.c VCAN_LCD_CH.c VCAN_LCD_ST7735R.c VCAN_LCD_ST7735S.c VCAN_LED.C VCAN_NRF24L0.c VCAN_NRF24L0_MSG.c VCAN_TSL1401.c VCAN_UI_VAR.c
  group Chip
    ../../Lib/Chip/inc/: common.h
    ../../Lib/Chip/src/: KEA_adc.c KEA_ftm.c KEA_gpio.c KEA_PIT.c KEA_port.c KEA_SysTick.c KEA_uart.c KEA_wdog.c misc.c vectors.c
    ../../Lib/Chip/src/IAR/: startup_SKEAZ1284.s system_SKEAZ1284.c
